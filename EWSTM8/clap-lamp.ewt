<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Lib</name>
    <file>
      <name>$PROJ_DIR$\..\Lib\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Lib\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Lib\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Lib\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Lib\src\stm8s_tim2.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm8s_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\stm8s_it.h</name>
    </file>
  </group>
</project>


